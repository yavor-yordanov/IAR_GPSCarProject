# IAR project GPSCarProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; C:\Users\Yavor\Desktop\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include; C:\Users\Yavor\Documents\IAR_GPSCarProject\STM32F4xx_StdPeriphDrv; C:\Users\Yavor\Documents\IAR_GPSCarProject\STM32F4_Discovery; C:\Users\Yavor\Documents\IAR_GPSCarProject\fatfs; C:\Users\Yavor\Documents\IAR_GPSCarProject\fatfs_drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: GPSCarProject.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Com_Parser
    ComParser/: ComParser.c
  group EWARM
    ../../Desktop/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group FatFS_Driver
    fatfs/: diskio.c ff.c
    fatfs_drivers/: fatfs_sd_sdio.c tm_stm32f4_fatfs.c
  group GPS
    stm32f407_GPSLibrary/: tm_stm32f4_gps.c
  group LED_Driver
    stm32f407_LEDLibrary/: stm32f407_LedDrv.c
  group Servo
    stm32f407_ServoLibrary/: tm_stm32f4_pwm.c tm_stm32f4_servo.c tm_stm32f4_timer_properties.c
  group STM32F4-Discovery
    STM32F4_Discovery/: stm32f4_discovery.c
  group STM32Fxx_StdPeriphDriver
    STM32F4xx_StdPeriphDrv/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group USART
    stm32f407_USARTLibrary/: tm_stm32f4_usart.c
  group User
    ./: main.c system_stm32f4xx.c
